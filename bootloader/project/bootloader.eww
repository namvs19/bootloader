<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\application\project\app.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\bootloader.ewp</path>
    </project>
    <batchBuild />
</workspace>
