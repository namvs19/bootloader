# IAR project app.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 NXP MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKL46Z256VLL4
  ICCARM.CCIncludePath2: ..\CMSIS\Include; ..\MKL46Z4; ..\include; ..\source; ..\drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: app.srec
  ILINK.IlinkOutputFile: app.out
  ILINK.IlinkIcfFile: ..\MKL46Z256xxx4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\CMSIS\Include; ..\MKL46Z4; ..\libraries; ..\source; ..\source\drivers
  ICCARM.CCOptLevel: 3
  group drivers
    ../drivers/: Timer.c UART0.c
  group source
    ../source/: main.c
  group startup
    ../MKL46Z4/: startup_MKL46Z4.s system_MKL46Z4.c system_MKL46Z4.h
